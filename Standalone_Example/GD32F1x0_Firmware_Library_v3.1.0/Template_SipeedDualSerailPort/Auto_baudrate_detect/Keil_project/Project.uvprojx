# Keil uVision project Project.uvprojx, settings and files
target GD32F130_150 (6150000::V6.15::ARMCLANG)
  device: GD32F150R8 GigaDevice
  pack: GigaDevice.GD32F1x0_DFP.3.2.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x08000000-0x0800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Project +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32F130_150
  c include: ..\..\..\Firmware\CMSIS\GD\GD32F1x0\Include;..\..\..\Utilities;..\..\..\Firmware\CMSIS;..\..\Auto_baudrate_detect;..\..\..\Firmware\CMSIS\GD\GD32F1x0\Source\ARM;..\..\..\Firmware\GD32F1x0_standard_peripheral\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application
    ../: gd32f1x0_it.c main.c systick.c
  group CMSIS
    ../../../Firmware/CMSIS/GD/GD32F1x0/Source/: system_gd32f1x0.c
    ../../../Firmware/CMSIS/GD/GD32F1x0/Source/ARM/: startup_gd32f1x0.s
  group Peripherals
    ../../../Firmware/GD32F1x0_standard_peripheral/Source/: gd32f1x0_adc.c gd32f1x0_can.c gd32f1x0_cec.c gd32f1x0_cmp.c gd32f1x0_crc.c gd32f1x0_dac.c gd32f1x0_dbg.c gd32f1x0_dma.c gd32f1x0_exti.c gd32f1x0_fmc.c gd32f1x0_fwdgt.c gd32f1x0_gpio.c gd32f1x0_i2c.c gd32f1x0_ivref.c gd32f1x0_misc.c gd32f1x0_opa.c gd32f1x0_pmu.c gd32f1x0_rcu.c gd32f1x0_rtc.c gd32f1x0_slcd.c gd32f1x0_spi.c gd32f1x0_syscfg.c gd32f1x0_timer.c gd32f1x0_tsi.c gd32f1x0_usart.c gd32f1x0_wwdgt.c
  group Utilities
    ../../../Utilities/: gd32f1x0_eval.c
  group Doc
    ../: readme.txt
target GD32F170_190 (ARM-ADS)
  device: GD32F190R8 GigaDevice
  cpu: as above
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F170_190
  c include: ..\..\..\Firmware\CMSIS\GD\GD32F1x0\Include;..\..\..\Utilities;..\..\..\Firmware\CMSIS;..\..\Template;..\..\..\Firmware\CMSIS\GD\GD32F1x0\Source\ARM;..\..\..\Firmware\GD32F1x0_standard_peripheral\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
